Commit message: Removed error-prone constructor for Pose2/Pose3

File: test/pendulum.urdf (robot description, URDF)
Before this commit: robot pendulum, 3 links, 2 joints
Joints:
- joint pendulum_joint: axis -1 0 0 -> 0 0 1; origin xyz=0.18 0 0.0 rpy=3.14159625 0 0 -> xyz=0 0.18 0.0 rpy=0 0 0
